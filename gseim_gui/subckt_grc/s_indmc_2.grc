options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_indmc_2
    title: s_indmc_2
  states: {}

blocks:
- name: abc_to_dq$0
  id: abc_to_dq
  parameters:
    name: none
  states: {}
- name: indmc2a$0
  id: indmc2a
  parameters:
    j: j
    llr: llr
    lls: lls
    lm: lm
    name: none
    poles: poles
    rr: rr
    rs: rs
  states: {}
- name: indmc2b$0
  id: indmc2b
  parameters:
    llr: llr
    lls: lls
    lm: lm
    name: none
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: wrm
    type: complex
  states: {}
- name: pad_sink$1
  id: pad_sink
  parameters:
    label: ia
    type: complex
  states: {}
- name: pad_sink$2
  id: pad_sink
  parameters:
    label: ib
    type: complex
  states: {}
- name: pad_sink$3
  id: pad_sink
  parameters:
    label: ic
    type: complex
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: va
    type: complex
  states: {}
- name: pad_source$1
  id: pad_source
  parameters:
    label: vb
    type: complex
  states: {}
- name: pad_source$2
  id: pad_source
  parameters:
    label: vc
    type: complex
  states: {}
- name: pad_source$3
  id: pad_source
  parameters:
    label: tl
    type: complex
  states: {}

connections:
- [abc_to_dq$0, '0', indmc2a$0, '0']
- [abc_to_dq$0, '1', indmc2a$0, '1']
- [indmc2a$0, '0', pad_sink$0, '0']
- [indmc2a$0, '1', indmc2b$0, '0']
- [indmc2a$0, '2', indmc2b$0, '1']
- [indmc2a$0, '3', indmc2b$0, '2']
- [indmc2a$0, '4', indmc2b$0, '3']
- [indmc2b$0, '0', pad_sink$1, '0']
- [indmc2b$0, '1', pad_sink$2, '0']
- [indmc2b$0, '2', pad_sink$3, '0']
- [pad_source$0, '0', abc_to_dq$0, '0']
- [pad_source$1, '0', abc_to_dq$0, '1']
- [pad_source$2, '0', abc_to_dq$0, '2']
- [pad_source$3, '0', indmc2a$0, '2']

metadata:
  file_format: 1
