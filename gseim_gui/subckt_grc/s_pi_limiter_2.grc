options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_pi_limiter_2
    title: PI control (limiter)
  states: {}

blocks:
- name: integrator_1$0
  id: integrator_1
  parameters:
    k: k
    name: none
    tau: tau
    y_ig: '0.0'
    y_st: y20
  states: {}
- name: limiter$0
  id: limiter
  parameters:
    name: none
    xmax: xmax
    xmin: xmin
  states: {}
- name: limiter$1
  id: limiter
  parameters:
    name: none
    xmax: xmax
    xmin: xmin
  states: {}
- name: multscl$0
  id: multscl
  parameters:
    k: k
    name: none
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: y
    type: float
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: x
    type: float
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}

connections:
- [integrator_1$0, '0', limiter$0, '0']
- [limiter$0, '0', sum_2$0, '1']
- [limiter$1, '0', pad_sink$0, '0']
- [multscl$0, '0', sum_2$0, '0']
- [pad_source$0, '0', integrator_1$0, '0']
- [pad_source$0, '0', multscl$0, '0']
- [sum_2$0, '0', limiter$1, '0']

metadata:
  file_format: 1
