options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_pwm_1
    title: PWM-1
  states: {}

blocks:
- name: cmpr_1_2$0
  id: cmpr_1_2
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '0'
    flag_quad: '0'
    name: none
    x0: '0.0'
    y_high: cmpr_high
    y_low: '0'
  states: {}
- name: cmpr_1_2$0$0
  id: cmpr_1_2
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '0'
    flag_quad: '0'
    name: none
    x0: '0.0'
    y_high: cmpr_high
    y_low: '0'
  states: {}
- name: cmpr_1_2$0$0$0
  id: cmpr_1_2
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '0'
    flag_quad: '0'
    name: none
    x0: '0.0'
    y_high: cmpr_high
    y_low: '0'
  states: {}
- name: diff$0
  id: diff
  parameters:
    name: none
  states: {}
- name: diff$0$0
  id: diff
  parameters:
    name: none
  states: {}
- name: diff$0$1
  id: diff
  parameters:
    name: none
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: g1
    type: complex
  states: {}
- name: pad_sink$1
  id: pad_sink
  parameters:
    label: g2
    type: complex
  states: {}
- name: pad_sink$2
  id: pad_sink
  parameters:
    label: g3
    type: complex
  states: {}
- name: pad_sink$3
  id: pad_sink
  parameters:
    label: g4
    type: complex
  states: {}
- name: pad_sink$4
  id: pad_sink
  parameters:
    label: g5
    type: complex
  states: {}
- name: pad_sink$5
  id: pad_sink
  parameters:
    label: g6
    type: complex
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: va
    type: complex
  states: {}
- name: pad_source$1
  id: pad_source
  parameters:
    label: vb
    type: complex
  states: {}
- name: pad_source$2
  id: pad_source
  parameters:
    label: vc
    type: complex
  states: {}
- name: triangle_2$0
  id: triangle_2
  parameters:
    L1: tri_low
    L2: tri_high
    T: T
    name: none
    t0: '0'
  states: {}

connections:
- [cmpr_1_2$0, '0', pad_sink$0, '0']
- [cmpr_1_2$0, '1', pad_sink$3, '0']
- [cmpr_1_2$0$0, '0', pad_sink$2, '0']
- [cmpr_1_2$0$0, '1', pad_sink$5, '0']
- [cmpr_1_2$0$0$0, '0', pad_sink$4, '0']
- [cmpr_1_2$0$0$0, '1', pad_sink$1, '0']
- [diff$0, '0', cmpr_1_2$0, '0']
- [diff$0$0, '0', cmpr_1_2$0$0, '0']
- [diff$0$1, '0', cmpr_1_2$0$0$0, '0']
- [pad_source$0, '0', diff$0, '0']
- [pad_source$1, '0', diff$0$0, '0']
- [pad_source$2, '0', diff$0$1, '0']
- [triangle_2$0, '0', diff$0, '1']
- [triangle_2$0, '0', diff$0$0, '1']
- [triangle_2$0, '0', diff$0$1, '1']

metadata:
  file_format: 1
