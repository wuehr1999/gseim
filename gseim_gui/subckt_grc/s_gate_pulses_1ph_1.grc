options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_gate_pulses_1ph_1
    title: Gate pulses (1ph)-1
  states: {}

blocks:
- name: and_2$0
  id: and_2
  parameters:
    name: none
    y_high: y_high
  states: {}
- name: and_2$1
  id: and_2
  parameters:
    name: none
    y_high: y_high
  states: {}
- name: cmpr_1_1$0
  id: cmpr_1_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '1'
    flag_quad: '0'
    name: none
    x0: hb2
    y_high: y_high
    y_low: '0'
  states: {}
- name: cmpr_1_1$0$0
  id: cmpr_1_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '1'
    flag_quad: '0'
    name: none
    x0: hb2
    y_high: y_high
    y_low: '0'
  states: {}
- name: cmpr_2_1$0
  id: cmpr_2_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '0'
    flag_quad: '0'
    name: none
    y_high: y_high
    y_low: '0'
  states: {}
- name: cmpr_2_1$1
  id: cmpr_2_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    flag_invert: '0'
    flag_quad: '0'
    name: none
    y_high: y_high
    y_low: '0'
  states: {}
- name: lag_2$0
  id: lag_2
  parameters:
    name: none
    t_delay: t_delay
    y_st: '0.0'
  states: {}
- name: lag_2$1
  id: lag_2
  parameters:
    name: none
    t_delay: t_delay
    y_st: '0.0'
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: y1
    type: float
  states: {}
- name: pad_sink$1
  id: pad_sink
  parameters:
    label: y2
    type: float
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: x1
    type: float
  states: {}
- name: pad_source$1
  id: pad_source
  parameters:
    label: x2
    type: float
  states: {}

connections:
- [and_2$0, '0', pad_sink$0, '0']
- [and_2$1, '0', pad_sink$1, '0']
- [cmpr_1_1$0, '0', and_2$1, '0']
- [cmpr_1_1$0$0, '0', and_2$0, '1']
- [cmpr_2_1$0, '0', and_2$0, '0']
- [cmpr_2_1$0, '0', lag_2$0, '0']
- [cmpr_2_1$1, '0', and_2$1, '1']
- [cmpr_2_1$1, '0', lag_2$1, '0']
- [lag_2$0, '0', cmpr_1_1$0, '0']
- [lag_2$1, '0', cmpr_1_1$0$0, '0']
- [pad_source$0, '0', cmpr_2_1$0, '0']
- [pad_source$0, '0', cmpr_2_1$1, '1']
- [pad_source$1, '0', cmpr_2_1$0, '1']
- [pad_source$1, '0', cmpr_2_1$1, '0']

metadata:
  file_format: 1
