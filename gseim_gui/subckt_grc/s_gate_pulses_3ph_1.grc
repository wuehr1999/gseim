options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_gate_pulses_3ph_1
    title: Gate pulses (3ph)-1
  states: {}

blocks:
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: g1
    type: complex
  states: {}
- name: pad_sink$1
  id: pad_sink
  parameters:
    label: g2
    type: complex
  states: {}
- name: pad_sink$2
  id: pad_sink
  parameters:
    label: g3
    type: complex
  states: {}
- name: pad_sink$3
  id: pad_sink
  parameters:
    label: g4
    type: complex
  states: {}
- name: pad_sink$4
  id: pad_sink
  parameters:
    label: g5
    type: complex
  states: {}
- name: pad_sink$5
  id: pad_sink
  parameters:
    label: g6
    type: complex
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: a
    type: complex
  states: {}
- name: pad_source$1
  id: pad_source
  parameters:
    label: b
    type: complex
  states: {}
- name: pad_source$2
  id: pad_source
  parameters:
    label: c
    type: complex
  states: {}
- name: pad_source$3
  id: pad_source
  parameters:
    label: ref
    type: complex
  states: {}
- name: s_gate_pulses_1ph_1$0
  id: s_gate_pulses_1ph_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    name: none
    t_delay: t_delay
    y_high: y_high
  states: {}
- name: s_gate_pulses_1ph_1$1
  id: s_gate_pulses_1ph_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    name: none
    t_delay: t_delay
    y_high: y_high
  states: {}
- name: s_gate_pulses_1ph_1$2
  id: s_gate_pulses_1ph_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    name: none
    t_delay: t_delay
    y_high: y_high
  states: {}

connections:
- [pad_source$0, '0', s_gate_pulses_1ph_1$0, '0']
- [pad_source$1, '0', s_gate_pulses_1ph_1$1, '0']
- [pad_source$2, '0', s_gate_pulses_1ph_1$2, '0']
- [pad_source$3, '0', s_gate_pulses_1ph_1$0, '1']
- [pad_source$3, '0', s_gate_pulses_1ph_1$1, '1']
- [pad_source$3, '0', s_gate_pulses_1ph_1$2, '1']
- [s_gate_pulses_1ph_1$0, '0', pad_sink$0, '0']
- [s_gate_pulses_1ph_1$0, '1', pad_sink$3, '0']
- [s_gate_pulses_1ph_1$1, '0', pad_sink$2, '0']
- [s_gate_pulses_1ph_1$1, '1', pad_sink$5, '0']
- [s_gate_pulses_1ph_1$2, '0', pad_sink$4, '0']
- [s_gate_pulses_1ph_1$2, '1', pad_sink$1, '0']

metadata:
  file_format: 1
