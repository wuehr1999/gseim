options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_indmc
    title: s_indmc
  states: {}

blocks:
- name: abc_to_dq$0
  id: abc_to_dq
  parameters: {}
  states: {}
- name: dummy_sink$0
  id: dummy_sink
  parameters:
    n: wr
  states: {}
- name: dummy_sink$1
  id: dummy_sink
  parameters:
    n: psiqr
  states: {}
- name: dummy_sink$2
  id: dummy_sink
  parameters:
    n: psidr
  states: {}
- name: dummy_sink$3
  id: dummy_sink
  parameters:
    n: ids
  states: {}
- name: dummy_sink$4
  id: dummy_sink
  parameters:
    n: idr
  states: {}
- name: dummy_sink$5
  id: dummy_sink
  parameters:
    n: iqr
  states: {}
- name: dummy_sink$6
  id: dummy_sink
  parameters:
    n: iqs
  states: {}
- name: dummy_source$0
  id: dummy_source
  parameters:
    n: ids
  states: {}
- name: dummy_source$0$0
  id: dummy_source
  parameters:
    n: ids
  states: {}
- name: dummy_source$1
  id: dummy_source
  parameters:
    n: iqs
  states: {}
- name: dummy_source$1$0
  id: dummy_source
  parameters:
    n: iqs
  states: {}
- name: dummy_source$2
  id: dummy_source
  parameters:
    n: idr
  states: {}
- name: dummy_source$2$0
  id: dummy_source
  parameters:
    n: idr
  states: {}
- name: dummy_source$3
  id: dummy_source
  parameters:
    n: iqr
  states: {}
- name: dummy_source$3$0
  id: dummy_source
  parameters:
    n: iqr
  states: {}
- name: dummy_source$4
  id: dummy_source
  parameters:
    n: psidr
  states: {}
- name: dummy_source$4$0
  id: dummy_source
  parameters:
    n: psidr
  states: {}
- name: dummy_source$5
  id: dummy_source
  parameters:
    n: psiqr
  states: {}
- name: dummy_source$5$0
  id: dummy_source
  parameters:
    n: psiqr
  states: {}
- name: dummy_source$6
  id: dummy_source
  parameters:
    n: wr
  states: {}
- name: integrator$0
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: integrator$1
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: integrator$2
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: integrator$3
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: integrator$4
  id: integrator
  parameters:
    k: i1_k
    name: i1
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: mult_2$0
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$1
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$2
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$2$0
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: multscl$0
  id: multscl
  parameters:
    k: x2
    name: none
  states: {}
- name: multscl$1
  id: multscl
  parameters:
    k: m1_k
    name: m1
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: wrm
    type: complex
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: tl
    type: complex
  states: {}
- name: pad_source$1
  id: pad_source
  parameters:
    label: va
    type: complex
  states: {}
- name: pad_source$2
  id: pad_source
  parameters:
    label: vb
    type: complex
  states: {}
- name: pad_source$3
  id: pad_source
  parameters:
    label: vc
    type: complex
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: s1_k1
    k2: s1_k2
    name: s1
  states: {}
- name: sum_2$1
  id: sum_2
  parameters:
    k1: s2_k1
    k2: s2_k2
    name: s2
  states: {}
- name: sum_2$2
  id: sum_2
  parameters:
    k1: s3_k1
    k2: s3_k2
    name: s3
  states: {}
- name: sum_2$3
  id: sum_2
  parameters:
    k1: s4_k1
    k2: s4_k2
    name: s4
  states: {}
- name: sum_2$4
  id: sum_2
  parameters:
    k1: '-1'
    k2: '1'
    name: s5
  states: {}
- name: sum_2$5
  id: sum_2
  parameters:
    k1: s8_k1
    k2: s8_k2
    name: s8
  states: {}
- name: sum_2$6
  id: sum_2
  parameters:
    k1: s6_k1
    k2: s6_k2
    name: s6
  states: {}
- name: sum_2$7
  id: sum_2
  parameters:
    k1: s7_k1
    k2: s7_k2
    name: s7
  states: {}
- name: sum_2$8
  id: sum_2
  parameters:
    k1: s9_k1
    k2: s9_k2
    name: s9
  states: {}
- name: sum_2$9
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '-1.0'
    name: none
  states: {}

connections:
- [abc_to_dq$0, '0', sum_2$1, '0']
- [abc_to_dq$0, '1', sum_2$0, '0']
- [dummy_source$0, '0', sum_2$0, '1']
- [dummy_source$0$0, '0', mult_2$1, '0']
- [dummy_source$1, '0', sum_2$1, '1']
- [dummy_source$1$0, '0', mult_2$0, '0']
- [dummy_source$2, '0', sum_2$2, '0']
- [dummy_source$2$0, '0', mult_2$0, '1']
- [dummy_source$3, '0', sum_2$3, '0']
- [dummy_source$3$0, '0', mult_2$1, '1']
- [dummy_source$4, '0', mult_2$2$0, '1']
- [dummy_source$4$0, '0', sum_2$6, '1']
- [dummy_source$5, '0', mult_2$2, '0']
- [dummy_source$5$0, '0', sum_2$7, '1']
- [dummy_source$6, '0', mult_2$2, '1']
- [dummy_source$6, '0', mult_2$2$0, '0']
- [integrator$0, '0', sum_2$5, '0']
- [integrator$0, '0', sum_2$6, '0']
- [integrator$1, '0', sum_2$7, '0']
- [integrator$1, '0', sum_2$8, '0']
- [integrator$2, '0', dummy_sink$2, '0']
- [integrator$3, '0', dummy_sink$1, '0']
- [integrator$4, '0', multscl$0, '0']
- [integrator$4, '0', pad_sink$0, '0']
- [mult_2$0, '0', sum_2$9, '0']
- [mult_2$1, '0', sum_2$9, '1']
- [mult_2$2, '0', sum_2$2, '1']
- [mult_2$2$0, '0', sum_2$3, '1']
- [multscl$0, '0', dummy_sink$0, '0']
- [multscl$1, '0', sum_2$4, '1']
- [pad_source$0, '0', sum_2$4, '0']
- [pad_source$1, '0', abc_to_dq$0, '0']
- [pad_source$2, '0', abc_to_dq$0, '1']
- [pad_source$3, '0', abc_to_dq$0, '2']
- [sum_2$0, '0', integrator$0, '0']
- [sum_2$1, '0', integrator$1, '0']
- [sum_2$2, '0', integrator$2, '0']
- [sum_2$3, '0', integrator$3, '0']
- [sum_2$4, '0', integrator$4, '0']
- [sum_2$5, '0', dummy_sink$4, '0']
- [sum_2$6, '0', dummy_sink$3, '0']
- [sum_2$6, '0', sum_2$5, '1']
- [sum_2$7, '0', dummy_sink$6, '0']
- [sum_2$7, '0', sum_2$8, '1']
- [sum_2$8, '0', dummy_sink$5, '0']
- [sum_2$9, '0', multscl$1, '0']

metadata:
  file_format: 1
