options:
  parameters:
    author: mbp
    generate_options: hb
    id: s_pi
    title: PI control
  states: {}

blocks:
- name: integrator$0
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: y20
  states: {}
- name: multscl$0
  id: multscl
  parameters:
    k: Kp
    name: none
  states: {}
- name: multscl$1
  id: multscl
  parameters:
    k: Ki
    name: none
  states: {}
- name: pad_sink$0
  id: pad_sink
  parameters:
    label: y
    type: float
  states: {}
- name: pad_source$0
  id: pad_source
  parameters:
    label: x
    type: float
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}

connections:
- [integrator$0, '0', multscl$1, '0']
- [multscl$0, '0', sum_2$0, '0']
- [multscl$1, '0', sum_2$0, '1']
- [pad_source$0, '0', integrator$0, '0']
- [pad_source$0, '0', multscl$0, '0']
- [sum_2$0, '0', pad_sink$0, '0']

metadata:
  file_format: 1
