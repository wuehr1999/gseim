options:
  parameters:
    author: mbp
    generate_options: circuit
    id: test_limiter
    title: test limiter
  states: {}

blocks:
- name: limiter$0
  id: limiter
  parameters:
    name: none
    xmax: '1.0'
    xmin: '-1'
  states: {}
- name: srcac$0
  id: srcac
  parameters:
    a: '1.8'
    dc: '0'
    f_hz: '1'
    name: none
    phi_deg: '0'
    t0: '0'
  states: {}

connections:
- [srcac$0, '0', limiter$0, '0']

metadata:
  file_format: 1
