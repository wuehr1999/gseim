options:
  parameters:
    author: mbp
    generate_options: circuit
    id: test_filter_1
    title: test_filter_1
  states: {}

blocks:
- name: filter_1$0
  id: filter_1
  parameters:
    a0: '0'
    a1: '0.00318'
    a2: '0'
    a3: '0'
    a4: '0'
    a5: '0'
    b0: '1.0'
    b1: '0.00318'
    b2: '0'
    b3: '0'
    b4: '0'
    b5: '0'
    f0: '0.0'
    name: none
    scale_coef: '0'
    x_sv: '0.0'
    y_sv: '0.0'
  states: {}
- name: srcac$0
  id: srcac
  parameters:
    a: '1'
    dc: '0'
    f_hz: '40'
    name: none
    phi_deg: '0'
    t0: '0'
  states: {}

connections:
- [srcac$0, '0', filter_1$0, '0']

metadata:
  file_format: 1
