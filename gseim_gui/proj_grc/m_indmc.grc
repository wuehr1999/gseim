options:
  parameters:
    author: mbp
    generate_options: circuit
    id: m_indmc
    title: m_indmc
  states: {}

blocks:
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: s_indmc$0
  id: s_indmc
  parameters:
    comment: induction motor subckt
    i1_k: computed
    j: '0.089'
    llr: '0.002'
    lls: '0.002'
    lm: '0.0693'
    m1_k: computed
    name: motor1
    poles: '4'
    rr: '0.816'
    rs: '0.435'
    s1_k1: computed
    s1_k2: computed
    s2_k1: computed
    s2_k2: computed
    s3_k1: computed
    s3_k2: computed
    s4_k1: computed
    s4_k2: computed
    s6_k1: computed
    s6_k2: computed
    s7_k1: computed
    s7_k2: computed
    s8_k1: computed
    s8_k2: computed
    s9_k1: computed
    s9_k2: computed
    x2: computed
  states: {}
- name: srcac$0
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '-120'
    t0: '0'
  states: {}
- name: srcac$1
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '-240'
    t0: '0'
  states: {}
- name: srcac$2
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '0'
    t0: '0'
  states: {}

connections:
- [const$0, '0', s_indmc$0, '0']
- [srcac$0, '0', s_indmc$0, '2']
- [srcac$1, '0', s_indmc$0, '3']
- [srcac$2, '0', s_indmc$0, '1']

metadata:
  file_format: 1
