options:
  parameters:
    author: mbp
    generate_options: circuit
    id: m_indmc_1
    title: m_indmc_1
  states: {}

blocks:
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: s_indmc_2$0
  id: s_indmc_2
  parameters:
    j: '0.089'
    llr: '0.002'
    lls: '0.002'
    lm: '0.0693'
    name: motor1
    poles: '4'
    rr: '0.816'
    rs: '0.435'
  states: {}
- name: srcac$0
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '-120'
    t0: '0'
  states: {}
- name: srcac$1
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '-240'
    t0: '0'
  states: {}
- name: srcac$2
  id: srcac
  parameters:
    a: Vm
    dc: '0'
    f_hz: f_hz
    name: none
    phi_deg: '0'
    t0: '0'
  states: {}

connections:
- [const$0, '0', s_indmc_2$0, '3']
- [srcac$0, '0', s_indmc_2$0, '1']
- [srcac$1, '0', s_indmc_2$0, '2']
- [srcac$2, '0', s_indmc_2$0, '0']

metadata:
  file_format: 1
