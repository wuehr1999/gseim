options:
  parameters:
    author: mbp
    generate_options: circuit
    id: test_cmpr_1
    title: Comparator test
  states: {}

blocks:
- name: cmpr_1_1$0
  id: cmpr_1_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    epsl: '1.0e-6'
    name: none
    x0: '0.0'
    y_high: '1.0'
    y_low: '-1.0'
  states: {}
- name: srcac$0
  id: srcac
  parameters:
    a: '1'
    dc: '0'
    f_hz: '1'
    name: none
    phi_deg: '0'
    t0: '0'
  states: {}

connections:
- [srcac$0, '0', cmpr_1_1$0, '0']

metadata:
  file_format: 1
