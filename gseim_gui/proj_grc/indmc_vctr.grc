options:
  parameters:
    author: mbp
    generate_options: circuit
    id: indmc_vctr
    title: vector control
  states: {}

blocks:
- name: abc_to_dq_2$0
  id: abc_to_dq_2
  parameters: {}
  states: {}
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: const$1
  id: const
  parameters:
    k: '104.72'
    k_scale: '1'
    name: none
  states: {}
- name: const$2
  id: const
  parameters:
    k: '5.7'
    k_scale: '1'
    name: none
  states: {}
- name: cosine$0
  id: cosine
  parameters:
    name: none
  states: {}
- name: diff$0
  id: diff
  parameters:
    name: none
  states: {}
- name: diff$1
  id: diff
  parameters:
    name: none
  states: {}
- name: diff$2
  id: diff
  parameters:
    name: none
  states: {}
- name: diff$3
  id: diff
  parameters:
    name: none
  states: {}
- name: dq_to_abc$0
  id: dq_to_abc
  parameters: {}
  states: {}
- name: dummy_sink$0
  id: dummy_sink
  parameters:
    n: vsq_star
  states: {}
- name: dummy_sink$1
  id: dummy_sink
  parameters:
    n: vsd_star
  states: {}
- name: dummy_sink$10
  id: dummy_sink
  parameters:
    n: imr
  states: {}
- name: dummy_sink$2
  id: dummy_sink
  parameters:
    n: wrm
  states: {}
- name: dummy_sink$3
  id: dummy_sink
  parameters:
    n: wmr
  states: {}
- name: dummy_sink$4
  id: dummy_sink
  parameters:
    n: vsq_a
  states: {}
- name: dummy_sink$5
  id: dummy_sink
  parameters:
    n: vsd_a
  states: {}
- name: dummy_sink$6
  id: dummy_sink
  parameters:
    n: sint
  states: {}
- name: dummy_sink$7
  id: dummy_sink
  parameters:
    n: cost
  states: {}
- name: dummy_sink$8
  id: dummy_sink
  parameters:
    n: isd
  states: {}
- name: dummy_sink$9
  id: dummy_sink
  parameters:
    n: isq
  states: {}
- name: dummy_source$0
  id: dummy_source
  parameters:
    n: wrm
  states: {}
- name: dummy_source$1
  id: dummy_source
  parameters:
    n: imr
  states: {}
- name: dummy_source$12
  id: dummy_source
  parameters:
    n: wmr
  states: {}
- name: dummy_source$2
  id: dummy_source
  parameters:
    n: isq
  states: {}
- name: dummy_source$3
  id: dummy_source
  parameters:
    n: isd
  states: {}
- name: dummy_source$4
  id: dummy_source
  parameters:
    n: vsq_a
  states: {}
- name: dummy_source$5
  id: dummy_source
  parameters:
    n: vsd_a
  states: {}
- name: dummy_source$6
  id: dummy_source
  parameters:
    n: vsd_star
  states: {}
- name: dummy_source$7
  id: dummy_source
  parameters:
    n: vsq_star
  states: {}
- name: dummy_source$8
  id: dummy_source
  parameters:
    n: cost
  states: {}
- name: dummy_source$8$0
  id: dummy_source
  parameters:
    n: cost
  states: {}
- name: dummy_source$9
  id: dummy_source
  parameters:
    n: sint
  states: {}
- name: dummy_source$9$0
  id: dummy_source
  parameters:
    n: sint
  states: {}
- name: integrator$0
  id: integrator
  parameters:
    k: '1.0'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: lag_1$0
  id: lag_1
  parameters:
    name: none
    tr: tr
    y_st: '0.0'
  states: {}
- name: limiter$0
  id: limiter
  parameters:
    name: none
    xmax: '1.3'
    xmin: '-1.3'
  states: {}
- name: limiter$1
  id: limiter
  parameters:
    name: none
    xmax: '1.3'
    xmin: '-1.3'
  states: {}
- name: modulo_twopi$0
  id: modulo_twopi
  parameters:
    name: none
  states: {}
- name: s_gate_pulses_3ph_1$0
  id: s_gate_pulses_3ph_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    name: none
    t_delay: 2u
    y_high: x_high
  states: {}
- name: s_indmc_2$0
  id: s_indmc_2
  parameters:
    j: '0.25'
    llr: 6.2m
    lls: 6.2m
    lm: 139m
    name: none
    poles: '4'
    rr: '1.157'
    rs: '1.157'
  states: {}
- name: s_pi_limiter_2$0
  id: s_pi_limiter_2
  parameters:
    k: '1.55'
    name: none
    tau: '31.83'
    xmax: '13'
    xmin: '-13'
    y20: '0'
  states: {}
- name: s_pi_limiter_2$1
  id: s_pi_limiter_2
  parameters:
    k: '39.5'
    name: none
    tau: '0.0032'
    xmax: '10'
    xmin: '-10'
    y20: '0'
  states: {}
- name: s_pi_limiter_2$2
  id: s_pi_limiter_2
  parameters:
    k: '0.0496'
    name: none
    tau: '0.0105'
    xmax: '1.3'
    xmin: '-1.3'
    y20: '0'
  states: {}
- name: s_pi_limiter_2$3
  id: s_pi_limiter_2
  parameters:
    k: '0.0496'
    name: none
    tau: '0.0105'
    xmax: '0.293'
    xmin: '-0.293'
    y20: '0'
  states: {}
- name: sine$0
  id: sine
  parameters:
    name: none
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: sum_2$1
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: triangle_2$0
  id: triangle_2
  parameters:
    L1: x_high
    L2: x_low
    T: 204.9u
    name: none
    t0: '0'
  states: {}
- name: user_fn_4_3$0
  id: user_fn_4_3
  parameters:
    index_fn: '3'
    iprm1: poles
    iprm2: '1'
    name: none
    rprm1: sigma
    rprm10: '1'
    rprm2: ls
    rprm3: vdc
    rprm4: tr
    rprm5: '1'
    rprm6: '1'
    rprm7: '1'
    rprm8: '1'
    rprm9: '1'
  states: {}
- name: vsi_3ph_1$0
  id: vsi_3ph_1
  parameters:
    L: x_high
    name: none
    vdc: vdc
  states: {}

connections:
- [abc_to_dq_2$0, '0', dummy_sink$8, '0']
- [abc_to_dq_2$0, '0', lag_1$0, '0']
- [abc_to_dq_2$0, '0', user_fn_4_3$0, '1']
- [abc_to_dq_2$0, '1', dummy_sink$9, '0']
- [abc_to_dq_2$0, '1', user_fn_4_3$0, '2']
- [const$0, '0', s_indmc_2$0, '3']
- [const$1, '0', diff$0, '0']
- [const$2, '0', diff$1, '0']
- [cosine$0, '0', dummy_sink$7, '0']
- [diff$0, '0', s_pi_limiter_2$0, '0']
- [diff$1, '0', s_pi_limiter_2$1, '0']
- [diff$2, '0', s_pi_limiter_2$2, '0']
- [diff$3, '0', s_pi_limiter_2$3, '0']
- [dq_to_abc$0, '0', s_gate_pulses_3ph_1$0, '0']
- [dq_to_abc$0, '1', s_gate_pulses_3ph_1$0, '1']
- [dq_to_abc$0, '2', s_gate_pulses_3ph_1$0, '2']
- [dummy_source$0, '0', diff$0, '1']
- [dummy_source$1, '0', diff$1, '1']
- [dummy_source$12, '0', integrator$0, '0']
- [dummy_source$2, '0', diff$2, '1']
- [dummy_source$3, '0', diff$3, '1']
- [dummy_source$4, '0', sum_2$0, '1']
- [dummy_source$5, '0', sum_2$1, '1']
- [dummy_source$6, '0', dq_to_abc$0, '0']
- [dummy_source$7, '0', dq_to_abc$0, '1']
- [dummy_source$8, '0', dq_to_abc$0, '2']
- [dummy_source$8$0, '0', abc_to_dq_2$0, '3']
- [dummy_source$9, '0', dq_to_abc$0, '3']
- [dummy_source$9$0, '0', abc_to_dq_2$0, '4']
- [integrator$0, '0', cosine$0, '0']
- [integrator$0, '0', modulo_twopi$0, '0']
- [integrator$0, '0', sine$0, '0']
- [lag_1$0, '0', dummy_sink$10, '0']
- [lag_1$0, '0', user_fn_4_3$0, '3']
- [limiter$0, '0', dummy_sink$0, '0']
- [limiter$1, '0', dummy_sink$1, '0']
- [s_gate_pulses_3ph_1$0, '0', vsi_3ph_1$0, '0']
- [s_gate_pulses_3ph_1$0, '1', vsi_3ph_1$0, '1']
- [s_gate_pulses_3ph_1$0, '2', vsi_3ph_1$0, '2']
- [s_gate_pulses_3ph_1$0, '3', vsi_3ph_1$0, '3']
- [s_gate_pulses_3ph_1$0, '4', vsi_3ph_1$0, '4']
- [s_gate_pulses_3ph_1$0, '5', vsi_3ph_1$0, '5']
- [s_indmc_2$0, '0', dummy_sink$2, '0']
- [s_indmc_2$0, '0', user_fn_4_3$0, '0']
- [s_indmc_2$0, '1', abc_to_dq_2$0, '0']
- [s_indmc_2$0, '2', abc_to_dq_2$0, '1']
- [s_indmc_2$0, '3', abc_to_dq_2$0, '2']
- [s_pi_limiter_2$0, '0', diff$2, '0']
- [s_pi_limiter_2$1, '0', diff$3, '0']
- [s_pi_limiter_2$2, '0', sum_2$0, '0']
- [s_pi_limiter_2$3, '0', sum_2$1, '0']
- [sine$0, '0', dummy_sink$6, '0']
- [sum_2$0, '0', limiter$0, '0']
- [sum_2$1, '0', limiter$1, '0']
- [triangle_2$0, '0', s_gate_pulses_3ph_1$0, '3']
- [user_fn_4_3$0, '0', dummy_sink$5, '0']
- [user_fn_4_3$0, '1', dummy_sink$4, '0']
- [user_fn_4_3$0, '2', dummy_sink$3, '0']
- [vsi_3ph_1$0, '0', s_indmc_2$0, '0']
- [vsi_3ph_1$0, '1', s_indmc_2$0, '1']
- [vsi_3ph_1$0, '2', s_indmc_2$0, '2']

metadata:
  file_format: 1
