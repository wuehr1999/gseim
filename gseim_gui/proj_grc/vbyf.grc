options:
  parameters:
    author: mbp
    generate_options: circuit
    id: vbyf
    title: v by f control of induction motor
  states: {}

blocks:
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: const$0$0
  id: const
  parameters:
    k: '-2.094395'
    k_scale: '1'
    name: none
  states: {}
- name: const$0$0$0
  id: const
  parameters:
    k: '2.094395'
    k_scale: '1'
    name: none
  states: {}
- name: const$1
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: integrator$0
  id: integrator
  parameters:
    k: '314.1593'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: lag_1$0
  id: lag_1
  parameters:
    name: none
    tr: '0.25'
    y_st: '0.0'
  states: {}
- name: mult_2$0
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$1
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$2
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: pwl10_xy$0
  id: pwl10_xy
  parameters:
    n: '2'
    name: none
    x1: '0.2'
    x10: '10'
    x2: '1.0'
    x3: '3'
    x4: '4'
    x5: '5'
    x6: '6'
    x7: '7'
    x8: '8'
    x9: '9'
    y1: '0.2'
    y10: '10'
    y2: '1.0'
    y3: '3'
    y4: '4'
    y5: '5'
    y6: '6'
    y7: '7'
    y8: '8'
    y9: '9'
  states: {}
- name: pwl20$0
  id: pwl20
  parameters:
    n: '4.0'
    name: none
    t1: '0.1'
    t10: '10'
    t11: '11'
    t12: '12'
    t13: '13'
    t14: '14'
    t15: '15'
    t16: '16'
    t17: '17'
    t18: '18'
    t19: '19'
    t2: '0.11'
    t20: '20'
    t3: '20'
    t4: '20.01'
    t5: '5'
    t6: '6'
    t7: '7'
    t8: '8'
    t9: '9'
    v1: '0.0'
    v10: '10'
    v11: '11'
    v12: '12'
    v13: '13'
    v14: '14'
    v15: '15'
    v16: '16'
    v17: '17'
    v18: '18'
    v19: '19'
    v2: '1.0'
    v20: '20'
    v3: '1.0'
    v4: '0.5'
    v5: '5'
    v6: '6'
    v7: '7'
    v8: '8'
    v9: '9'
  states: {}
- name: s_indmc$0
  id: s_indmc
  parameters:
    i1_k: computed
    j: '0.25'
    llr: '9.6e-3'
    lls: '9.6e-3'
    lm: '241.9e-3'
    m1_k: computed
    poles: '4'
    rr: '1.6068'
    rs: '1.6068'
    s1_k1: computed
    s1_k2: computed
    s2_k1: computed
    s2_k2: computed
    s3_k1: computed
    s3_k2: computed
    s4_k1: computed
    s4_k2: computed
    s6_k1: computed
    s6_k2: computed
    s7_k1: computed
    s7_k2: computed
    s8_k1: computed
    s8_k2: computed
    s9_k1: computed
    s9_k2: computed
    x2: computed
  states: {}
- name: s_pwm_1$0
  id: s_pwm_1
  parameters:
    T: 500u
    cmpr_high: '1'
    delt_min: delt_min
    delt_nrml: delt_nrml
    flag_invert: '0'
    flag_quad: '0'
    name: none
    tri_high: '1'
    tri_low: '-1'
  states: {}
- name: sine$0
  id: sine
  parameters:
    name: none
  states: {}
- name: sine$1
  id: sine
  parameters:
    name: none
  states: {}
- name: sine$2
  id: sine
  parameters:
    name: none
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: sum_2$0$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: sum_2$0$0$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: vsi_3ph_1$0
  id: vsi_3ph_1
  parameters:
    L: '1.0'
    name: none
    vdc: '615'
  states: {}

connections:
- [const$0, '0', sum_2$0, '0']
- [const$0$0, '0', sum_2$0$0, '0']
- [const$0$0$0, '0', sum_2$0$0$0, '0']
- [const$1, '0', s_indmc$0, '0']
- [integrator$0, '0', sum_2$0, '1']
- [integrator$0, '0', sum_2$0$0, '1']
- [integrator$0, '0', sum_2$0$0$0, '1']
- [lag_1$0, '0', integrator$0, '0']
- [lag_1$0, '0', pwl10_xy$0, '0']
- [mult_2$0, '0', s_pwm_1$0, '0']
- [mult_2$1, '0', s_pwm_1$0, '1']
- [mult_2$2, '0', s_pwm_1$0, '2']
- [pwl10_xy$0, '0', mult_2$0, '1']
- [pwl10_xy$0, '0', mult_2$1, '1']
- [pwl10_xy$0, '0', mult_2$2, '1']
- [pwl20$0, '0', lag_1$0, '0']
- [s_pwm_1$0, '0', vsi_3ph_1$0, '0']
- [s_pwm_1$0, '1', vsi_3ph_1$0, '1']
- [s_pwm_1$0, '2', vsi_3ph_1$0, '2']
- [s_pwm_1$0, '3', vsi_3ph_1$0, '3']
- [s_pwm_1$0, '4', vsi_3ph_1$0, '4']
- [s_pwm_1$0, '5', vsi_3ph_1$0, '5']
- [sine$0, '0', mult_2$0, '0']
- [sine$1, '0', mult_2$1, '0']
- [sine$2, '0', mult_2$2, '0']
- [sum_2$0, '0', sine$0, '0']
- [sum_2$0$0, '0', sine$1, '0']
- [sum_2$0$0$0, '0', sine$2, '0']
- [vsi_3ph_1$0, '0', s_indmc$0, '1']
- [vsi_3ph_1$0, '1', s_indmc$0, '2']
- [vsi_3ph_1$0, '2', s_indmc$0, '3']

metadata:
  file_format: 1
