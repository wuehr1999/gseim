options:
  parameters:
    author: mbp
    generate_options: circuit
    id: pi_indmc
    title: PI control of induction motor
  states: {}

blocks:
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: const$0$0
  id: const
  parameters:
    k: '-2.094395'
    k_scale: '1'
    name: none
  states: {}
- name: const$0$0$0
  id: const
  parameters:
    k: '2.094395'
    k_scale: '1'
    name: none
  states: {}
- name: const$2
  id: const
  parameters:
    k: '100'
    k_scale: '1'
    name: none
  states: {}
- name: diff$0
  id: diff
  parameters:
    name: none
  states: {}
- name: dummy_sink$0
  id: dummy_sink
  parameters:
    n: wrm
  states: {}
- name: dummy_sink$1
  id: dummy_sink
  parameters:
    n: A
  states: {}
- name: dummy_source$0
  id: dummy_source
  parameters:
    n: wrm
  states: {}
- name: dummy_source$1
  id: dummy_source
  parameters:
    n: A
  states: {}
- name: integrator$0
  id: integrator
  parameters:
    k: '314.1593'
    name: none
    y_ig: '0.0'
    y_st: '0.0'
  states: {}
- name: lag_1$0
  id: lag_1
  parameters:
    name: none
    tr: '1.25'
    y_st: '0.0'
  states: {}
- name: mult_2$0
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$1
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: mult_2$2
  id: mult_2
  parameters:
    k: '1.0'
    name: none
  states: {}
- name: pwl20$0
  id: pwl20
  parameters:
    n: '4'
    name: none
    t1: '40'
    t10: '10'
    t11: '11'
    t12: '12'
    t13: '13'
    t14: '14'
    t15: '15'
    t16: '16'
    t17: '17'
    t18: '18'
    t19: '19'
    t2: '40.1'
    t20: '20'
    t3: '55'
    t4: '55.1'
    t5: '5'
    t6: '6'
    t7: '7'
    t8: '8'
    t9: '9'
    v1: '0'
    v10: '10'
    v11: '11'
    v12: '12'
    v13: '13'
    v14: '14'
    v15: '15'
    v16: '16'
    v17: '17'
    v18: '18'
    v19: '19'
    v2: 1.9e3
    v20: '20'
    v3: 1.9e3
    v4: '0'
    v5: '5'
    v6: '6'
    v7: '7'
    v8: '8'
    v9: '9'
  states: {}
- name: s_indmc_1$0
  id: s_indmc_1
  parameters:
    j: '11.06'
    llr: '3.2e-3'
    lls: '3.2e-3'
    lm: '143.25e-3'
    name: none
    poles: '4'
    rr: '0.187'
    rs: '0.262'
  states: {}
- name: s_pi$0
  id: s_pi
  parameters:
    Ki: '2.5e-3'
    Kp: '2.5e-2'
    name: none
    y20: '0'
  states: {}
- name: s_pwm_1$0
  id: s_pwm_1
  parameters:
    T: 1m
    cmpr_high: '1'
    delt_min: delt_min
    delt_nrml: delt_nrml
    flag_invert: '0'
    flag_quad: '0'
    name: none
    tri_high: '1'
    tri_low: '-1'
  states: {}
- name: sine$0
  id: sine
  parameters:
    name: none
  states: {}
- name: sine$1
  id: sine
  parameters:
    name: none
  states: {}
- name: sine$2
  id: sine
  parameters:
    name: none
  states: {}
- name: sum_2$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: sum_2$0$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: sum_2$0$0$0
  id: sum_2
  parameters:
    k1: '1.0'
    k2: '1.0'
    name: none
  states: {}
- name: vsi_3ph_1$0
  id: vsi_3ph_1
  parameters:
    L: '1.0'
    name: none
    vdc: '3000'
  states: {}

connections:
- [const$0, '0', sum_2$0, '0']
- [const$0$0, '0', sum_2$0$0, '0']
- [const$0$0$0, '0', sum_2$0$0$0, '0']
- [const$2, '0', diff$0, '0']
- [diff$0, '0', lag_1$0, '0']
- [dummy_source$0, '0', diff$0, '1']
- [dummy_source$1, '0', mult_2$0, '1']
- [dummy_source$1, '0', mult_2$1, '1']
- [dummy_source$1, '0', mult_2$2, '1']
- [integrator$0, '0', sum_2$0, '1']
- [integrator$0, '0', sum_2$0$0, '1']
- [integrator$0, '0', sum_2$0$0$0, '1']
- [lag_1$0, '0', s_pi$0, '0']
- [mult_2$0, '0', s_pwm_1$0, '0']
- [mult_2$1, '0', s_pwm_1$0, '1']
- [mult_2$2, '0', s_pwm_1$0, '2']
- [pwl20$0, '0', s_indmc_1$0, '3']
- [s_indmc_1$0, '0', dummy_sink$0, '0']
- [s_pi$0, '0', dummy_sink$1, '0']
- [s_pi$0, '0', integrator$0, '0']
- [s_pwm_1$0, '0', vsi_3ph_1$0, '0']
- [s_pwm_1$0, '1', vsi_3ph_1$0, '1']
- [s_pwm_1$0, '2', vsi_3ph_1$0, '2']
- [s_pwm_1$0, '3', vsi_3ph_1$0, '3']
- [s_pwm_1$0, '4', vsi_3ph_1$0, '4']
- [s_pwm_1$0, '5', vsi_3ph_1$0, '5']
- [sine$0, '0', mult_2$0, '0']
- [sine$1, '0', mult_2$1, '0']
- [sine$2, '0', mult_2$2, '0']
- [sum_2$0, '0', sine$0, '0']
- [sum_2$0$0, '0', sine$1, '0']
- [sum_2$0$0$0, '0', sine$2, '0']
- [vsi_3ph_1$0, '0', s_indmc_1$0, '0']
- [vsi_3ph_1$0, '1', s_indmc_1$0, '1']
- [vsi_3ph_1$0, '2', s_indmc_1$0, '2']

metadata:
  file_format: 1
