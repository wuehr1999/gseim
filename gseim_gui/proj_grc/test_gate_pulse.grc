options:
  parameters:
    author: mbp
    comment: |-
      compare triangle with constant and generate non-overlapping
      gate pulses
    description: testing of gate_pulses_1ph_1
    generate_options: circuit
    id: test_gate_pulse_1
    title: test gate pulse
  states: {}

blocks:
- name: const$0
  id: const
  parameters:
    k: '0'
    k_scale: '1'
    name: none
  states: {}
- name: s_gate_pulses_1ph_1$0
  id: s_gate_pulses_1ph_1
  parameters:
    delt_min: delt_min
    delt_nrml: delt_nrml
    name: none
    t_delay: '0.5e-3'
    y_high: y_high
  states: {}
- name: triangle_2$0
  id: triangle_2
  parameters:
    L1: '1'
    L2: '-1'
    T: 8m
    name: none
    t0: '0'
  states: {}

connections:
- [const$0, '0', s_gate_pulses_1ph_1$0, '1']
- [triangle_2$0, '0', s_gate_pulses_1ph_1$0, '0']

metadata:
  file_format: 1
